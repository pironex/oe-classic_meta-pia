DEFAULT_PREFERENCE = "-1"

PR_append = "+pia001"

# workaround for older OE:
THISDIR := "${@os.path.dirname(bb.data.getVar('FILE', d, True))}"
FILESPATHBASE_prepend := "${THISDIR}/files:"
