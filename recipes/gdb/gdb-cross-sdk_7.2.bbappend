PR_append = "+pia001"

export CFLAGS_append=" -L${STAGING_LIBDIR} -Wno-error=sizeof-pointer-memaccess"
