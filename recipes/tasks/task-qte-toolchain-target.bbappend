PR_append = "+pia007"

RDEPENDS_${PN} += " \
	libqwt-dev \
	libsqlite-dev \
	libsocketcan-dev \
	opencv-dev \
	dbus-c++-dev \
	dbus-cxx-dev \
	libusb1-dev \
	libfcgi-dev \
"
