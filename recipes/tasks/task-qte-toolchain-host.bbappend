PR_append = "+pia008"

RDEPENDS_${PN} += " dbus-c++-sdk dbus-c++-sdk-dbg"
