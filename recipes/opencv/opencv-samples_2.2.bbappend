SRC_URI = "git://code.opencv.org/opencv_attic.git;protocol=git;branch=2.2 \
"

SRCREV = "6778b81c75b0693b34e88b40563f10e5d2f12474"
PV = "2.2.0+gitr${SRCREV}"

S = "${WORKDIR}/git/opencv"
