PR_append = "+pia002"

EXTRA_OECONF_append += " \
    --extra-libs-mplayer='-lXext -lX11' \
"